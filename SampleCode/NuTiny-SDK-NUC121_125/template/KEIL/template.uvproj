# Keil uVision project template.uvproj, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC125SC2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: LED_Toggle +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC121\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC121.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC121/Source/: system_NUC121.c
    ../../../../Library/Device/Nuvoton/NUC121/Source/ARM/: startup_NUC121.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c usci_spi.c pdma.c
